RDEPENDS:${PN}:class-native = "bash openssl-bin binutils findutils file"
