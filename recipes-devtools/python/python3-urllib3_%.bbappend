CVE_STATUS[CVE-2025-50182] = "not-applicable-platform: only for the Pyodide runtime"
