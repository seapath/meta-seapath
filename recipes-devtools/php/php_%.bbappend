PACKAGECONFIG:remove = "mysql"
