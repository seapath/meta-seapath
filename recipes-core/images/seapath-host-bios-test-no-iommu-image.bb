# Copyright (C) 2021, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "A test image for Seapath with bios support"
require seapath-test-common.inc
WKS_FILE = "mkbiosdisk_no_iommu.wks.in"
