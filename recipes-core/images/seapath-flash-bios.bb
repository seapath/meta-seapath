# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "An image working on BIOS machine used to flash other Seapath images"
require recipes-core/images/seapath-flash-common.inc

WKS_FILE = "mkefidisk-bios-flasher.wks.in"
