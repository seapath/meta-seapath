# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A debug image for Seapath"
require seapath-host-common.inc
require seapath-dbg-common.inc
