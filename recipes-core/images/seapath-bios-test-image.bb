# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A test image for rte with bios support"
require rte-test-image.bb
WKS_FILE = "mkefidisk-bios.wks.in"
