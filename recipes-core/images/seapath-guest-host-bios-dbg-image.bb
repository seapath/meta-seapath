# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "A debug host and guest image for Seapath"
require seapath-guest-host-bios-test-image.bb
require seapath-dbg-common.inc
