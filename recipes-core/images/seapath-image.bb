# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A production image for rte"
require rte-host-common.inc
