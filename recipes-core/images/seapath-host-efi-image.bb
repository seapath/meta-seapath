# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "A production image for Seapath"
require seapath-host-common.inc
require seapath-efi-common.inc
require seapath-swupdate-common.inc

require conf/distro/include/traceability/seapath-host-efi-image/anssi-nt28-rev12.inc
