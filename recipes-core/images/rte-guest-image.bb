# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A guest production image for rte"
require rte-guest-common.inc
