DESCRIPTION = "A debug image for rte with bios support"
require rte-host-common.inc
require rte-dbg-common.inc

WKS_FILE = "mkefidisk-bios.wks.in"
