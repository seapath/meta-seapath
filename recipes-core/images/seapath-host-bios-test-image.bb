# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "A test image for Seapath with bios support"
require seapath-host-efi-test-image.bb
WKS_FILE = "mkbiosdisk.wks.in"
