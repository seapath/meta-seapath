# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A guest production image for Seapath"
require seapath-guest-common.inc
