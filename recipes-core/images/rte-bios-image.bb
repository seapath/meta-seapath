# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A production image for rte with bios support"
require rte-host-common.inc
WKS_FILE = "mkefidisk-bios.wks.in"
