# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A debug image for Seapath with bios support"
require seapath-host-common.inc
require seapath-dbg-common.inc

WKS_FILE = "mkefidisk-bios.wks.in"
