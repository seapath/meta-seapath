DESCRIPTION = "A production image for rte"
require rte-common.inc
