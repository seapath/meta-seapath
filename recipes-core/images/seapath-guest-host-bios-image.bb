# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "A host and guest production image for Seapath"
require seapath-guest-host-common.inc
