# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "A debug guest image for Seapath"
require seapath-guest-common.inc
require seapath-dbg-common.inc
require seapath-guest-test-common.inc
