# Copyright (C) 2020, RTE (http://www.rte-france.com)

DESCRIPTION = "A production image for Seapath with bios support"
require seapath-host-common.inc
WKS_FILE = "mkefidisk-bios.wks.in"
