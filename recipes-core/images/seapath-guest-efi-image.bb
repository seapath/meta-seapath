# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

DESCRIPTION = "A guest production image for Seapath"
require seapath-guest-common.inc

require conf/distro/include/traceability/seapath-guest-efi-image/anssi-nt28-rev12.inc
