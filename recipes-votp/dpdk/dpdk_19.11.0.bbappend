RDEPENDS_${PN}_append = " pciutils"
