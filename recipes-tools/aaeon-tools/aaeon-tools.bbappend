# Copyright (C) 2025, SFL (https://savoirfairelinux.com)
# SPDX-License-Identifier: Apache-2.0

EXTRA_UBOOT_BOOTLOADER_FILE ?= ""
