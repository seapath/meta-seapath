# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

SYSTEMD_AUTO_ENABLE = "disable"
