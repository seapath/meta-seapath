# This recipe has been generated with devtool
# Regenerating the shrinkwrap file and the list of licenses in the recipe can be done using the following command:
# devtool add --npm-dev https://github.com/seapath/cockpit-update.git -B main

SUMMARY = "cockpit cluster update"

LICENSE = "0BSD & Apache-2.0 & BSD-3-Clause & ISC & LGPL-2.1-only & MIT & CC-BY-3.0 & CC0-1.0 & BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327 \
                    file://node_modules/@nodelib/fs.scandir/LICENSE;md5=580f1c3c6765fecfdb93bdf4e068d952 \
                    file://node_modules/@nodelib/fs.stat/LICENSE;md5=580f1c3c6765fecfdb93bdf4e068d952 \
                    file://node_modules/@nodelib/fs.walk/LICENSE;md5=580f1c3c6765fecfdb93bdf4e068d952 \
                    file://node_modules/@patternfly/react-core/LICENSE;md5=39ed6d8640fd0499baa65f5f2aa88f56 \
                    file://node_modules/@patternfly/react-core/src/helpers/Popper/thirdparty/popper-core/LICENSE.md;md5=a40e4e94f7a8ca8e2883d3ec3674eae4 \
                    file://node_modules/@patternfly/react-core/src/helpers/Popper/thirdparty/react-popper/LICENSE;md5=89c7f77a1f3e44c5bc782da97c314245 \
                    file://node_modules/@patternfly/react-icons/LICENSE;md5=39ed6d8640fd0499baa65f5f2aa88f56 \
                    file://node_modules/@patternfly/react-styles/LICENSE;md5=39ed6d8640fd0499baa65f5f2aa88f56 \
                    file://node_modules/@patternfly/react-table/LICENSE;md5=39ed6d8640fd0499baa65f5f2aa88f56 \
                    file://node_modules/@patternfly/react-tokens/LICENSE;md5=39ed6d8640fd0499baa65f5f2aa88f56 \
                    file://node_modules/@remix-run/router/LICENSE.md;md5=4871ae884c1a5b4307340c3c723b3c78 \
                    file://node_modules/ansi-styles/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/anymatch/LICENSE;md5=12cd52ddd05803f07238d49743e68e37 \
                    file://node_modules/argparse/LICENSE;md5=a2f2590d8d82b0fa2b3e2fc5c69d2b81 \
                    file://node_modules/array-buffer-byte-length/LICENSE;md5=03c1a46f1c5121c7eb2cd13d6cb56831 \
                    file://node_modules/array-union/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/arraybuffer.prototype.slice/LICENSE;md5=968ec55067e4739372aa780aab6b3f11 \
                    file://node_modules/attr-accept/LICENSE;md5=3c7e0bf8e1a8b8aedc1e9d6ce478067a \
                    file://node_modules/autolinker/LICENSE;md5=c1499d3362e65b9112efcb39a97d8ba8 \
                    file://node_modules/available-typed-arrays/LICENSE;md5=838b75dc6028daf3e04e57871b7ad3ed \
                    file://node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/binary-extensions/license;md5=6c593968ebdd2bea3d4492d893155c74 \
                    file://node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/braces/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
                    file://node_modules/buffer-builder/LICENSE.txt;md5=14487d1e99bdc395a857f1ead44f010b \
                    file://node_modules/call-bind/LICENSE;md5=0eb2c73daa0ecf037cbdf3d0bb0c98d5 \
                    file://node_modules/chalk/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/chokidar/LICENSE;md5=385493bcd68524333269db742d243165 \
                    file://node_modules/cockpit-repo/COPYING;md5=4fbd65380cdd255951079008b364516c \
                    file://node_modules/cockpit-repo/src/bridge/mock-resource/system/cockpit/test-priority/sub/COPYING;md5=4fbd65380cdd255951079008b364516c \
                    file://node_modules/cockpit-repo/src/bridge/mock-resource/system/cockpit/test/sub/COPYING;md5=4fbd65380cdd255951079008b364516c \
                    file://node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/cross-spawn/LICENSE;md5=6046ffd2c9edcd9052bb4dd794d12f95 \
                    file://node_modules/data-view-buffer/LICENSE;md5=06aae85028f50ba69e6f83b6c9402b26 \
                    file://node_modules/data-view-byte-length/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/data-view-byte-offset/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/date-fns/LICENSE.md;md5=92c56b1dd99b39de686553383430b294 \
                    file://node_modules/deep-equal/LICENSE;md5=ec4e94fe7abda03e2e44a713b0908a07 \
                    file://node_modules/define-data-property/LICENSE;md5=06aae85028f50ba69e6f83b6c9402b26 \
                    file://node_modules/define-properties/LICENSE;md5=53ffc646fdb83e45279cfe7105e5157b \
                    file://node_modules/dir-glob/license;md5=05240cd20679544d6e90fcff746425bc \
                    file://node_modules/error-ex/LICENSE;md5=e67c75e89656b80fd99cb7d30fb43102 \
                    file://node_modules/es-abstract/LICENSE;md5=8eddf3932f9ef22313648669213a2e4b \
                    file://node_modules/es-define-property/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/es-errors/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/es-get-iterator/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/es-object-atoms/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/es-set-tostringtag/LICENSE;md5=92e9d482d23fb5be48580cb5e3d82a22 \
                    file://node_modules/es-to-primitive/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/esbuild-plugin-copy/LICENSE;md5=6553729d0f30d45f9f8f8e962a020275 \
                    file://node_modules/esbuild-plugin-copy/node_modules/fs-extra/LICENSE;md5=ea817882455c03503f7d014a8f54f095 \
                    file://node_modules/esbuild-plugin-replace/LICENSE;md5=fbb3c659451b81c361c85a75bd8798b6 \
                    file://node_modules/esbuild-sass-plugin/LICENSE;md5=d596bd534bc8a013afe74ea24af7e93b \
                    file://node_modules/esbuild/LICENSE.md;md5=46b907b175628fe6d2a5258b252970fa \
                    file://node_modules/escape-string-regexp/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/fast-glob/LICENSE;md5=580f1c3c6765fecfdb93bdf4e068d952 \
                    file://node_modules/fastq/LICENSE;md5=78523ef0bd3eb9fefc799bbe84780631 \
                    file://node_modules/file-selector/LICENSE;md5=27c5091e28777ad682696478e1ed1a54 \
                    file://node_modules/fill-range/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
                    file://node_modules/focus-trap/LICENSE;md5=11fb7eb4ad04d94add4876d6456d03b5 \
                    file://node_modules/for-each/LICENSE;md5=726a37665a35c687bf935f1503efee20 \
                    file://node_modules/fs-extra/LICENSE;md5=ea817882455c03503f7d014a8f54f095 \
                    file://node_modules/function-bind/LICENSE;md5=e7417c1a8ad83f88bcac21ad440d48b2 \
                    file://node_modules/function.prototype.name/LICENSE;md5=7d84e54df3d29e3cbd74b7368b844db4 \
                    file://node_modules/functions-have-names/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/get-intrinsic/LICENSE;md5=0eb2c73daa0ecf037cbdf3d0bb0c98d5 \
                    file://node_modules/get-symbol-description/LICENSE;md5=a026b78b6909aa5e21d77709fb6b5156 \
                    file://node_modules/glob-parent/LICENSE;md5=a3d42bb676c62db87cbf7b04d98da83e \
                    file://node_modules/globalthis/LICENSE;md5=7d84e54df3d29e3cbd74b7368b844db4 \
                    file://node_modules/globby/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/gopd/LICENSE;md5=8478c87d16770f6d32a4578c475d3930 \
                    file://node_modules/graceful-fs/LICENSE;md5=163972d49c2f7a3d3b687aeb48e9e3c9 \
                    file://node_modules/has-bigints/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/has-flag/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/has-property-descriptors/LICENSE;md5=d237eac07663bde2409de740ba75ec97 \
                    file://node_modules/has-proto/LICENSE;md5=d237eac07663bde2409de740ba75ec97 \
                    file://node_modules/has-symbols/LICENSE;md5=afee57a289508ed4df3456667778aaf6 \
                    file://node_modules/has-tostringtag/LICENSE;md5=a026b78b6909aa5e21d77709fb6b5156 \
                    file://node_modules/hasown/LICENSE;md5=19283ee92f78c91154834571c1f05a94 \
                    file://node_modules/hosted-git-info/LICENSE;md5=a01f10cd299d5727263720d47cc2c908 \
                    file://node_modules/ignore/LICENSE-MIT;md5=df4fe86855c0c73f4a52d5e556826c48 \
                    file://node_modules/immutable/LICENSE;md5=645df6b9bb08d017560ea0913ff4b7f2 \
                    file://node_modules/internal-slot/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/is-arguments/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
                    file://node_modules/is-array-buffer/LICENSE;md5=db2b446565e5f8d6041d1c10fb307510 \
                    file://node_modules/is-arrayish/LICENSE;md5=e67c75e89656b80fd99cb7d30fb43102 \
                    file://node_modules/is-bigint/LICENSE;md5=291be6f19f64188a89ffd5180aea06f7 \
                    file://node_modules/is-binary-path/license;md5=da0684b7c90dcea9333d6517f4fbda22 \
                    file://node_modules/is-boolean-object/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-callable/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-core-module/LICENSE;md5=02b0fb5ff4014a08fd4193bc3e2349e2 \
                    file://node_modules/is-data-view/LICENSE;md5=7b5e8558141b64e8475183ea02f2de77 \
                    file://node_modules/is-date-object/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-extglob/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/is-glob/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/is-map/LICENSE;md5=c18cc44449ec61c93b216bf74e6c4fa4 \
                    file://node_modules/is-negative-zero/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
                    file://node_modules/is-number-object/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-number/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
                    file://node_modules/is-regex/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
                    file://node_modules/is-set/LICENSE;md5=c18cc44449ec61c93b216bf74e6c4fa4 \
                    file://node_modules/is-shared-array-buffer/LICENSE;md5=a026b78b6909aa5e21d77709fb6b5156 \
                    file://node_modules/is-string/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-symbol/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-typed-array/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-weakmap/LICENSE;md5=c18cc44449ec61c93b216bf74e6c4fa4 \
                    file://node_modules/is-weakref/LICENSE;md5=838b75dc6028daf3e04e57871b7ad3ed \
                    file://node_modules/is-weakset/LICENSE;md5=c18cc44449ec61c93b216bf74e6c4fa4 \
                    file://node_modules/isarray/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/isexe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/js-sha1/LICENSE.txt;md5=e87820cf073014655c5b690af15a10cc \
                    file://node_modules/js-sha256/LICENSE.txt;md5=12f8ba8880693b7a588a3bbea523a8ed \
                    file://node_modules/js-tokens/LICENSE;md5=1d63bea73a26ffaf5e964ce74d3b83a5 \
                    file://node_modules/json-parse-better-errors/LICENSE.md;md5=048cc2006d506256349ca6088641486b \
                    file://node_modules/json-stable-stringify-without-jsonify/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/jsonfile/LICENSE;md5=423f377ade95936f6fe009b1c137bfdb \
                    file://node_modules/load-json-file/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/lodash/LICENSE;md5=8e2fca844c70b3833d7228885447c026 \
                    file://node_modules/loose-envify/LICENSE;md5=32e26a5793a4ffbace6131bc51567cb8 \
                    file://node_modules/magic-string/LICENSE;md5=17b8fdc59ea5ccf4488260421093f766 \
                    file://node_modules/memorystream/LICENSE;md5=159d0f91f0e8449cb027f4976bd87eb4 \
                    file://node_modules/merge2/LICENSE;md5=d8aa1e0b760adbfc8e07a9a6eb24a60e \
                    file://node_modules/micromatch/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
                    file://node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/nice-try/LICENSE;md5=ae2c9097ed1d346901fdc318eff30d78 \
                    file://node_modules/normalize-package-data/LICENSE;md5=745d0cb7803882ab26451fefb149878e \
                    file://node_modules/normalize-path/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
                    file://node_modules/npm-run-all/LICENSE;md5=893385a31dda2493704bc7f39bc976a0 \
                    file://node_modules/npm-run-all/node_modules/ansi-styles/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/npm-run-all/node_modules/chalk/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/npm-run-all/node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/npm-run-all/node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/npm-run-all/node_modules/has-flag/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/npm-run-all/node_modules/supports-color/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/object-inspect/LICENSE;md5=288162f1d1bfa064f127f2b42d2a656f \
                    file://node_modules/object-is/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
                    file://node_modules/object-keys/LICENSE;md5=0026e638d7d5c5f2768864ce0074f8ad \
                    file://node_modules/object.assign/LICENSE;md5=2b439ca9e99134dee172a7cc6d989174 \
                    file://node_modules/parse-json/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/path-key/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/path-parse/LICENSE;md5=4b940f9668dfcb796d2cb98ad94692df \
                    file://node_modules/path-type/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/picomatch/LICENSE;md5=abd0e25891525eb13d5a794f550a6ee4 \
                    file://node_modules/pidtree/license;md5=e13f2efb919ca0612717b069422598b7 \
                    file://node_modules/pify/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/possible-typed-array-names/LICENSE;md5=8fe23ea421aaf9f9d687709f6a6a09b7 \
                    file://node_modules/prop-types/LICENSE;md5=94f0d486b3ba1dd568004dc5cccd32bc \
                    file://node_modules/queue-microtask/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/react-dom/LICENSE;md5=901f6cd9846257b3a9c69dbd0a49caf1 \
                    file://node_modules/react-dropzone/LICENSE;md5=8f0d60a20295c7fbca6028745ccb4432 \
                    file://node_modules/react-is/LICENSE;md5=901f6cd9846257b3a9c69dbd0a49caf1 \
                    file://node_modules/react-router-dom/LICENSE.md;md5=4871ae884c1a5b4307340c3c723b3c78 \
                    file://node_modules/react-router/LICENSE.md;md5=4871ae884c1a5b4307340c3c723b3c78 \
                    file://node_modules/react/LICENSE;md5=901f6cd9846257b3a9c69dbd0a49caf1 \
                    file://node_modules/read-pkg/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/read-pkg/node_modules/path-type/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/readdirp/LICENSE;md5=d982124c58b759403329f9c0906aae7a \
                    file://node_modules/regexp.prototype.flags/LICENSE;md5=6009913822e586406a8cf459157e868a \
                    file://node_modules/remarkable/LICENSE;md5=48b1f60bd571e0dc660ee2c5743e64bd \
                    file://node_modules/resolve/LICENSE;md5=baa47288b5bd3e657a01886ce3dd0cb6 \
                    file://node_modules/reusify/LICENSE;md5=64af5da073cd15043e95dc5b443951ee \
                    file://node_modules/run-parallel/LICENSE;md5=fb42e5aa12bb9e365d38b4b5691d6984 \
                    file://node_modules/rxjs/LICENSE.txt;md5=80ca6de0630df9d3c3faee86819caa57 \
                    file://node_modules/safe-array-concat/LICENSE;md5=06aae85028f50ba69e6f83b6c9402b26 \
                    file://node_modules/safe-regex-test/LICENSE;md5=8478c87d16770f6d32a4578c475d3930 \
                    file://node_modules/sass-embedded-linux-musl-x64/dart-sass/src/LICENSE;md5=4c151434938b50596016c6abc33f6c7d \
                    file://node_modules/sass-embedded-linux-x64/dart-sass/src/LICENSE;md5=4c151434938b50596016c6abc33f6c7d \
                    file://node_modules/sass-embedded/LICENSE;md5=ae39313ff5797235eac0faf1bb98e514 \
                    file://node_modules/sass-embedded/node_modules/supports-color/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/sass/LICENSE;md5=4c151434938b50596016c6abc33f6c7d \
                    file://node_modules/scheduler/LICENSE;md5=901f6cd9846257b3a9c69dbd0a49caf1 \
                    file://node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/set-function-length/LICENSE;md5=19283ee92f78c91154834571c1f05a94 \
                    file://node_modules/set-function-name/LICENSE;md5=19283ee92f78c91154834571c1f05a94 \
                    file://node_modules/shebang-command/license;md5=1801ea63a6ba2dfc429eb5f36d09e06f \
                    file://node_modules/shebang-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/shell-quote/LICENSE;md5=31f6d70a3b756797901b2aff55cc7d7a \
                    file://node_modules/side-channel/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/slash/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/source-map-js/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/sourcemap-codec/LICENSE;md5=fe86de92781b32da4a26ca689959c26d \
                    file://node_modules/spdx-correct/LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57 \
                    file://node_modules/spdx-expression-parse/LICENSE;md5=35a411d082d4487ab0e0287014cddf80 \
                    file://node_modules/sprintf-js/LICENSE;md5=ab40451de4e35c90f1b663b4fbd314a9 \
                    file://node_modules/stop-iteration-iterator/LICENSE;md5=06aae85028f50ba69e6f83b6c9402b26 \
                    file://node_modules/string.prototype.padend/LICENSE;md5=0d1020270dd80ad7a3a81ce3dbaeda22 \
                    file://node_modules/string.prototype.trim/LICENSE;md5=6475e27670715f30f712326eeb195e93 \
                    file://node_modules/string.prototype.trimend/LICENSE;md5=1e241a19d2d112b1db1a5c1c23216939 \
                    file://node_modules/string.prototype.trimstart/LICENSE;md5=1e241a19d2d112b1db1a5c1c23216939 \
                    file://node_modules/strip-bom/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/supports-color/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/supports-preserve-symlinks-flag/LICENSE;md5=d237eac07663bde2409de740ba75ec97 \
                    file://node_modules/tabbable/LICENSE;md5=faf65be8f439b913bb5e892b7684a729 \
                    file://node_modules/throttle-debounce/LICENSE.md;md5=d6ab53365f2edace170e37f21a0a7c11 \
                    file://node_modules/to-regex-range/LICENSE;md5=b561e0a423bedc9d9ca9c8c67d40abb9 \
                    file://node_modules/tslib/CopyrightNotice.txt;md5=cb391e9e435b114c07bee8f6754c4f98 \
                    file://node_modules/tslib/LICENSE.txt;md5=f938d99cba29007eeae26d80a9a4cfa6 \
                    file://node_modules/typed-array-buffer/LICENSE;md5=06aae85028f50ba69e6f83b6c9402b26 \
                    file://node_modules/typed-array-byte-length/LICENSE;md5=838b75dc6028daf3e04e57871b7ad3ed \
                    file://node_modules/typed-array-byte-offset/LICENSE;md5=838b75dc6028daf3e04e57871b7ad3ed \
                    file://node_modules/typed-array-length/LICENSE;md5=838b75dc6028daf3e04e57871b7ad3ed \
                    file://node_modules/unbox-primitive/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/universalify/LICENSE;md5=a734c6ad6e37a515025ac5e8e90ef786 \
                    file://node_modules/uuid/LICENSE.md;md5=353e680cdafd96bf30131cbb7b14a6e8 \
                    file://node_modules/validate-npm-package-license/LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57 \
                    file://node_modules/which-boxed-primitive/LICENSE;md5=375dc7ca936a14e9c29418d5263bd066 \
                    file://node_modules/which-collection/LICENSE;md5=c18cc44449ec61c93b216bf74e6c4fa4 \
                    file://node_modules/which-typed-array/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/which/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/xterm-addon-canvas/LICENSE;md5=f26090141cc8b051033a6868211602d3 \
                    file://node_modules/xterm/LICENSE;md5=a6f7d231a2745fd8aaa465e2dd7c7c04 \
                    file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10 \
                    file://${COMMON_LICENSE_DIR}/BSD-3-Clause;md5=550794465ba0ec5312d6919e203a55f9 \
                    file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302 \
                    file://${COMMON_LICENSE_DIR}/CC-BY-3.0;md5=dfa02b5755629022e267f10b9c0a2ab7 \
                    file://${COMMON_LICENSE_DIR}/CC0-1.0;md5=0ceb3372c9595f0a8067e55da801e4a1 \
                    file://${COMMON_LICENSE_DIR}/BSD-2-Clause;md5=cb641bc04cda31daea161b1bc15da69f"

LICENSE:${PN} = "Apache-2.0"
LICENSE:${PN}-bufbuild-protobuf = "Apache-2.0 AND BSD-3-Clause"
LICENSE:${PN}-esbuild-linux-x64 = "MIT"
LICENSE:${PN}-nodelib-fsscandir = "MIT"
LICENSE:${PN}-nodelib-fsstat = "MIT"
LICENSE:${PN}-nodelib-fswalk = "MIT"
LICENSE:${PN}-patternfly-patternfly = "MIT"
LICENSE:${PN}-patternfly-react-core = "MIT"
LICENSE:${PN}-patternfly-react-icons = "MIT"
LICENSE:${PN}-patternfly-react-styles = "MIT"
LICENSE:${PN}-patternfly-react-table = "MIT"
LICENSE:${PN}-patternfly-react-tokens = "MIT"
LICENSE:${PN}-remix-run-router = "MIT"
LICENSE:${PN}-ansi-styles = "MIT"
LICENSE:${PN}-anymatch = "ISC"
LICENSE:${PN}-argparse = "MIT"
LICENSE:${PN}-array-buffer-byte-length = "MIT"
LICENSE:${PN}-array-union = "MIT"
LICENSE:${PN}-arraybufferprototypeslice = "MIT"
LICENSE:${PN}-attr-accept = "MIT"
LICENSE:${PN}-autolinker = "MIT"
LICENSE:${PN}-available-typed-arrays = "MIT"
LICENSE:${PN}-balanced-match = "MIT"
LICENSE:${PN}-binary-extensions = "MIT"
LICENSE:${PN}-brace-expansion = "MIT"
LICENSE:${PN}-braces = "MIT"
LICENSE:${PN}-buffer-builder = "MIT"
LICENSE:${PN}-call-bind = "MIT"
LICENSE:${PN}-chalk = "MIT"
LICENSE:${PN}-chokidar = "MIT"
LICENSE:${PN}-cockpit-repo = "LGPL-2.1-only"
LICENSE:${PN}-color-convert = "MIT"
LICENSE:${PN}-color-name = "MIT"
LICENSE:${PN}-concat-map = "MIT"
LICENSE:${PN}-cross-spawn = "MIT"
LICENSE:${PN}-data-view-buffer = "MIT"
LICENSE:${PN}-data-view-byte-length = "MIT"
LICENSE:${PN}-data-view-byte-offset = "MIT"
LICENSE:${PN}-date-fns = "MIT"
LICENSE:${PN}-deep-equal = "MIT"
LICENSE:${PN}-define-data-property = "MIT"
LICENSE:${PN}-define-properties = "MIT"
LICENSE:${PN}-dir-glob = "MIT"
LICENSE:${PN}-error-ex = "MIT"
LICENSE:${PN}-es-abstract = "MIT"
LICENSE:${PN}-es-define-property = "MIT"
LICENSE:${PN}-es-errors = "MIT"
LICENSE:${PN}-es-get-iterator = "MIT"
LICENSE:${PN}-es-object-atoms = "MIT"
LICENSE:${PN}-es-set-tostringtag = "MIT"
LICENSE:${PN}-es-to-primitive = "MIT"
LICENSE:${PN}-esbuild = "MIT"
LICENSE:${PN}-esbuild-plugin-copy-fs-extra = "MIT"
LICENSE:${PN}-esbuild-plugin-copy = "MIT"
LICENSE:${PN}-esbuild-plugin-replace = "MIT"
LICENSE:${PN}-esbuild-sass-plugin = "MIT"
LICENSE:${PN}-escape-string-regexp = "MIT"
LICENSE:${PN}-fast-glob = "MIT"
LICENSE:${PN}-fastq = "ISC"
LICENSE:${PN}-file-selector = "MIT"
LICENSE:${PN}-fill-range = "MIT"
LICENSE:${PN}-focus-trap = "MIT"
LICENSE:${PN}-for-each = "MIT"
LICENSE:${PN}-fs-extra = "MIT"
LICENSE:${PN}-function-bind = "MIT"
LICENSE:${PN}-functionprototypename = "MIT"
LICENSE:${PN}-functions-have-names = "MIT"
LICENSE:${PN}-get-intrinsic = "MIT"
LICENSE:${PN}-get-symbol-description = "MIT"
LICENSE:${PN}-glob-parent = "ISC"
LICENSE:${PN}-globalthis = "MIT"
LICENSE:${PN}-globby = "MIT"
LICENSE:${PN}-gopd = "MIT"
LICENSE:${PN}-graceful-fs = "ISC"
LICENSE:${PN}-has-bigints = "MIT"
LICENSE:${PN}-has-flag = "MIT"
LICENSE:${PN}-has-property-descriptors = "MIT"
LICENSE:${PN}-has-proto = "MIT"
LICENSE:${PN}-has-symbols = "MIT"
LICENSE:${PN}-has-tostringtag = "MIT"
LICENSE:${PN}-hasown = "MIT"
LICENSE:${PN}-hosted-git-info = "ISC"
LICENSE:${PN}-ignore = "MIT"
LICENSE:${PN}-immutable = "MIT"
LICENSE:${PN}-internal-slot = "MIT"
LICENSE:${PN}-is-arguments = "MIT"
LICENSE:${PN}-is-array-buffer = "MIT"
LICENSE:${PN}-is-arrayish = "MIT"
LICENSE:${PN}-is-bigint = "MIT"
LICENSE:${PN}-is-binary-path = "MIT"
LICENSE:${PN}-is-boolean-object = "MIT"
LICENSE:${PN}-is-callable = "MIT"
LICENSE:${PN}-is-core-module = "MIT"
LICENSE:${PN}-is-data-view = "MIT"
LICENSE:${PN}-is-date-object = "MIT"
LICENSE:${PN}-is-extglob = "MIT"
LICENSE:${PN}-is-glob = "MIT"
LICENSE:${PN}-is-map = "MIT"
LICENSE:${PN}-is-negative-zero = "MIT"
LICENSE:${PN}-is-number = "MIT"
LICENSE:${PN}-is-number-object = "MIT"
LICENSE:${PN}-is-regex = "MIT"
LICENSE:${PN}-is-set = "MIT"
LICENSE:${PN}-is-shared-array-buffer = "MIT"
LICENSE:${PN}-is-string = "MIT"
LICENSE:${PN}-is-symbol = "MIT"
LICENSE:${PN}-is-typed-array = "MIT"
LICENSE:${PN}-is-weakmap = "MIT"
LICENSE:${PN}-is-weakref = "MIT"
LICENSE:${PN}-is-weakset = "MIT"
LICENSE:${PN}-isarray = "MIT"
LICENSE:${PN}-isexe = "ISC"
LICENSE:${PN}-js-sha1 = "MIT"
LICENSE:${PN}-js-sha256 = "MIT"
LICENSE:${PN}-js-tokens = "MIT"
LICENSE:${PN}-json-parse-better-errors = "MIT"
LICENSE:${PN}-json-stable-stringify-without-jsonify = "MIT"
LICENSE:${PN}-jsonfile = "MIT"
LICENSE:${PN}-load-json-file = "MIT"
LICENSE:${PN}-lodash = "MIT"
LICENSE:${PN}-loose-envify = "MIT"
LICENSE:${PN}-magic-string = "MIT"
LICENSE:${PN}-memorystream = "MIT"
LICENSE:${PN}-merge2 = "MIT"
LICENSE:${PN}-micromatch = "MIT"
LICENSE:${PN}-minimatch = "ISC"
LICENSE:${PN}-nice-try = "MIT"
LICENSE:${PN}-normalize-package-data = "BSD-2-Clause"
LICENSE:${PN}-normalize-path = "MIT"
LICENSE:${PN}-npm-run-all-ansi-styles = "MIT"
LICENSE:${PN}-npm-run-all-chalk = "MIT"
LICENSE:${PN}-npm-run-all-color-convert = "MIT"
LICENSE:${PN}-npm-run-all-color-name = "MIT"
LICENSE:${PN}-npm-run-all-has-flag = "MIT"
LICENSE:${PN}-npm-run-all-supports-color = "MIT"
LICENSE:${PN}-npm-run-all = "MIT"
LICENSE:${PN}-object-assign = "MIT"
LICENSE:${PN}-object-inspect = "MIT"
LICENSE:${PN}-object-is = "MIT"
LICENSE:${PN}-object-keys = "MIT"
LICENSE:${PN}-objectassign = "MIT"
LICENSE:${PN}-parse-json = "MIT"
LICENSE:${PN}-path-key = "MIT"
LICENSE:${PN}-path-parse = "MIT"
LICENSE:${PN}-path-type = "MIT"
LICENSE:${PN}-picomatch = "MIT"
LICENSE:${PN}-pidtree = "MIT"
LICENSE:${PN}-pify = "MIT"
LICENSE:${PN}-possible-typed-array-names = "MIT"
LICENSE:${PN}-prop-types = "MIT"
LICENSE:${PN}-queue-microtask = "MIT"
LICENSE:${PN}-react = "MIT"
LICENSE:${PN}-react-dom = "MIT"
LICENSE:${PN}-react-dropzone = "MIT"
LICENSE:${PN}-react-is = "MIT"
LICENSE:${PN}-react-router = "MIT"
LICENSE:${PN}-react-router-dom = "MIT"
LICENSE:${PN}-read-pkg-path-type = "MIT"
LICENSE:${PN}-read-pkg = "MIT"
LICENSE:${PN}-readdirp = "MIT"
LICENSE:${PN}-regexpprototypeflags = "MIT"
LICENSE:${PN}-remarkable = "MIT"
LICENSE:${PN}-resolve = "MIT"
LICENSE:${PN}-reusify = "MIT"
LICENSE:${PN}-run-parallel = "MIT"
LICENSE:${PN}-rxjs = "Apache-2.0"
LICENSE:${PN}-safe-array-concat = "MIT"
LICENSE:${PN}-safe-regex-test = "MIT"
LICENSE:${PN}-sass = "MIT"
LICENSE:${PN}-sass-embedded-supports-color = "MIT"
LICENSE:${PN}-sass-embedded = "MIT"
LICENSE:${PN}-sass-embedded-linux-musl-x64 = "MIT"
LICENSE:${PN}-sass-embedded-linux-x64 = "MIT"
LICENSE:${PN}-scheduler = "MIT"
LICENSE:${PN}-semver = "ISC"
LICENSE:${PN}-set-function-length = "MIT"
LICENSE:${PN}-set-function-name = "MIT"
LICENSE:${PN}-shebang-command = "MIT"
LICENSE:${PN}-shebang-regex = "MIT"
LICENSE:${PN}-shell-quote = "MIT"
LICENSE:${PN}-side-channel = "MIT"
LICENSE:${PN}-slash = "MIT"
LICENSE:${PN}-source-map-js = "BSD-3-Clause"
LICENSE:${PN}-sourcemap-codec = "MIT"
LICENSE:${PN}-spdx-correct = "Apache-2.0"
LICENSE:${PN}-spdx-exceptions = "CC-BY-3.0"
LICENSE:${PN}-spdx-expression-parse = "MIT"
LICENSE:${PN}-spdx-license-ids = "CC0-1.0"
LICENSE:${PN}-sprintf-js = "BSD-3-Clause"
LICENSE:${PN}-stop-iteration-iterator = "MIT"
LICENSE:${PN}-stringprototypepadend = "MIT"
LICENSE:${PN}-stringprototypetrim = "MIT"
LICENSE:${PN}-stringprototypetrimend = "MIT"
LICENSE:${PN}-stringprototypetrimstart = "MIT"
LICENSE:${PN}-strip-bom = "MIT"
LICENSE:${PN}-supports-color = "MIT"
LICENSE:${PN}-supports-preserve-symlinks-flag = "MIT"
LICENSE:${PN}-tabbable = "MIT"
LICENSE:${PN}-throttle-debounce = "MIT"
LICENSE:${PN}-to-regex-range = "MIT"
LICENSE:${PN}-tslib = "0BSD"
LICENSE:${PN}-typed-array-buffer = "MIT"
LICENSE:${PN}-typed-array-byte-length = "MIT"
LICENSE:${PN}-typed-array-byte-offset = "MIT"
LICENSE:${PN}-typed-array-length = "MIT"
LICENSE:${PN}-unbox-primitive = "MIT"
LICENSE:${PN}-universalify = "MIT"
LICENSE:${PN}-uuid = "MIT"
LICENSE:${PN}-validate-npm-package-license = "Apache-2.0"
LICENSE:${PN}-varint = "MIT"
LICENSE:${PN}-which = "ISC"
LICENSE:${PN}-which-boxed-primitive = "MIT"
LICENSE:${PN}-which-collection = "MIT"
LICENSE:${PN}-which-typed-array = "MIT"
LICENSE:${PN}-xterm = "MIT"
LICENSE:${PN}-xterm-addon-canvas = "MIT"

SRC_URI = " \
    git://github.com/seapath/cockpit-update.git;protocol=https;branch=main \
    npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json;dev=1 \
    "

SRCREV = "e5e3318976a7b7ae0819274d0ec7559724b6a1cd"

S = "${WORKDIR}/git"

# Avoid compilation errors and warnings due to already stripped files that are precompiled files provided by npm dependencies.
INSANE_SKIP:${PN}:append = "already-stripped"

inherit npm

NPM_INSTALL_DEV = "1"

do_compile() {
    mkdir -p ${S}/pkg
    cp -r ${S}/node_modules/cockpit-repo/pkg/lib ${S}/pkg/

    node ${S}/build.js
}

do_install() {
    install -d ${D}${datadir}/cockpit/${PN}

    install -m 0644 ${S}/dist/index.css ${D}${datadir}/cockpit/${PN}
    install -m 0644 ${S}/dist/index.html ${D}${datadir}/cockpit/${PN}
    install -m 0644 ${S}/dist/index.js ${D}${datadir}/cockpit/${PN}
    install -m 0644 ${S}/dist/manifest.json ${D}${datadir}/cockpit/${PN}
}

RDEPENDS:${PN} += "cockpit"

FILES:${PN} += "${datadir}/cockpit/${PN}"

# There are some precompiled files for x86_64 architecture used by npm dependencies
COMPATIBLE_HOST = '(x86_64).*-linux'
