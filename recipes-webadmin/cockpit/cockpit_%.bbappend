RDEPENDS:${PN}-networkmanager:remove:seapath-host = "networkmanager"
RDEPENDS:${PN}:append:seapath-host = " cockpit-config"
