# Copyright (C) 2020, RTE (http://www.rte-france.com)

PACKAGECONFIG_append = " cifsidmap"
