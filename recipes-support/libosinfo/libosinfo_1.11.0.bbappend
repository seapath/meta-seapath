# Copyright (C) 2024 Savoir-faire Linux, Inc.
# SPDX-License-Identifier: Apache-2.0

RDEPENDS:${PN} += "osinfo-db"
