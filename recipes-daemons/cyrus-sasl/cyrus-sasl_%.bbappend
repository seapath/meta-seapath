PACKAGECONFIG_append = " ntlm gssapi"
