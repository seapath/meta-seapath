# Copyright (C) 2020, RTE (http://www.rte-france.com)

SYSTEMD_AUTO_ENABLE = "disable"
