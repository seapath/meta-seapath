# SPDX-License-Identifier: Apache-2.0
# Copyright (C) 2024 Savoir-faire Linux, Inc

SKIP_RECIPE[cockpit-machines] = ""
