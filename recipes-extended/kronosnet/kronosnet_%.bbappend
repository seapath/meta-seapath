# Copyright (C) 2019-2023 Savoir-faire Linux, Inc.
# SPDX-License-Identifier: Apache-2.0

EXTRA_OECONF:append = " --disable-man"
