FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-virtlogd.service.in-remove-syscall-filter.patch"

