# Copyright (C) 2020, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

ALTERNATIVE_${PN} = "less"
ALTERNATIVE_PRIORITY = "100"
