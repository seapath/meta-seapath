# Copyright (C) 2021, RTE (http://www.rte-france.com)
# SPDX-License-Identifier: Apache-2.0

SRC_URI_remove = "http://linuxcontainers.org/downloads/${BPN}-${PV}.tar.gz"
SRC_URI_prepend = "http://linuxcontainers.org/downloads/lxc/${BPN}-${PV}.tar.gz "
